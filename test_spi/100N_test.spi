*** SPICE deck for cell 100N_test{sch} from library CUDA_SPICE
*** Created on Mon Dec 10, 2018 14:30:45
*** Last revised on Mon Dec 10, 2018 14:33:23
*** Written on Mon Dec 10, 2018 14:33:38 by Electric VLSI Design System, version 9.07
*** Layout tech: mocmos, foundry MOSIS
*** UC SPICE *** , MIN_RESIST 4.0, MIN_CAPAC 0.1FF
* Model cards are described in this file:
.include "C:\Users\Angelinia\Documents\ESE 370\Electric\22nm_HP.pm"

.global gnd vdd

*** TOP LEVEL CELL: 100N_test{sch}
Mnmos@0 net@52 net@1 gnd gnd N L=0.044U W=0.044U
Mnmos@1 net@81 net@52 gnd gnd N L=0.044U W=0.044U
Mnmos@2 net@11 net@81 gnd gnd N L=0.044U W=0.044U
Mnmos@3 net@15 net@11 gnd gnd N L=0.044U W=0.044U
Mnmos@4 net@20 net@15 gnd gnd N L=0.044U W=0.044U
Mnmos@5 net@24 net@20 gnd gnd N L=0.044U W=0.044U
Mnmos@6 net@27 net@24 gnd gnd N L=0.044U W=0.044U
Mnmos@7 net@31 net@27 gnd gnd N L=0.044U W=0.044U
Mnmos@8 net@36 net@31 gnd gnd N L=0.044U W=0.044U
Mnmos@9 net@34 net@36 gnd gnd N L=0.044U W=0.044U
Mnmos@10 net@165 net@111 gnd gnd N L=0.044U W=0.044U
Mnmos@11 net@120 net@165 gnd gnd N L=0.044U W=0.044U
Mnmos@12 net@123 net@120 gnd gnd N L=0.044U W=0.044U
Mnmos@13 net@114 net@123 gnd gnd N L=0.044U W=0.044U
Mnmos@14 net@113 net@114 gnd gnd N L=0.044U W=0.044U
Mnmos@15 net@121 net@113 gnd gnd N L=0.044U W=0.044U
Mnmos@16 net@122 net@121 gnd gnd N L=0.044U W=0.044U
Mnmos@17 net@145 net@122 gnd gnd N L=0.044U W=0.044U
Mnmos@18 net@150 net@145 gnd gnd N L=0.044U W=0.044U
Mnmos@19 net@148 net@150 gnd gnd N L=0.044U W=0.044U
Mnmos@20 net@256 net@202 gnd gnd N L=0.044U W=0.044U
Mnmos@21 net@211 net@256 gnd gnd N L=0.044U W=0.044U
Mnmos@22 net@214 net@211 gnd gnd N L=0.044U W=0.044U
Mnmos@23 net@205 net@214 gnd gnd N L=0.044U W=0.044U
Mnmos@24 net@204 net@205 gnd gnd N L=0.044U W=0.044U
Mnmos@25 net@212 net@204 gnd gnd N L=0.044U W=0.044U
Mnmos@26 net@213 net@212 gnd gnd N L=0.044U W=0.044U
Mnmos@27 net@236 net@213 gnd gnd N L=0.044U W=0.044U
Mnmos@28 net@241 net@236 gnd gnd N L=0.044U W=0.044U
Mnmos@29 net@239 net@241 gnd gnd N L=0.044U W=0.044U
Mnmos@30 net@347 net@293 gnd gnd N L=0.044U W=0.044U
Mnmos@31 net@302 net@347 gnd gnd N L=0.044U W=0.044U
Mnmos@32 net@305 net@302 gnd gnd N L=0.044U W=0.044U
Mnmos@33 net@296 net@305 gnd gnd N L=0.044U W=0.044U
Mnmos@34 net@295 net@296 gnd gnd N L=0.044U W=0.044U
Mnmos@35 net@303 net@295 gnd gnd N L=0.044U W=0.044U
Mnmos@36 net@304 net@303 gnd gnd N L=0.044U W=0.044U
Mnmos@37 net@327 net@304 gnd gnd N L=0.044U W=0.044U
Mnmos@38 net@332 net@327 gnd gnd N L=0.044U W=0.044U
Mnmos@39 net@330 net@332 gnd gnd N L=0.044U W=0.044U
Mnmos@40 net@438 net@384 gnd gnd N L=0.044U W=0.044U
Mnmos@41 net@393 net@438 gnd gnd N L=0.044U W=0.044U
Mnmos@42 net@396 net@393 gnd gnd N L=0.044U W=0.044U
Mnmos@43 net@387 net@396 gnd gnd N L=0.044U W=0.044U
Mnmos@44 net@386 net@387 gnd gnd N L=0.044U W=0.044U
Mnmos@45 net@394 net@386 gnd gnd N L=0.044U W=0.044U
Mnmos@46 net@395 net@394 gnd gnd N L=0.044U W=0.044U
Mnmos@47 net@418 net@395 gnd gnd N L=0.044U W=0.044U
Mnmos@48 net@423 net@418 gnd gnd N L=0.044U W=0.044U
Mnmos@49 net@421 net@423 gnd gnd N L=0.044U W=0.044U
Mnmos@50 net@893 net@475 gnd gnd N L=0.044U W=0.044U
Mnmos@51 net@484 net@893 gnd gnd N L=0.044U W=0.044U
Mnmos@52 net@487 net@484 gnd gnd N L=0.044U W=0.044U
Mnmos@53 net@478 net@487 gnd gnd N L=0.044U W=0.044U
Mnmos@54 net@477 net@478 gnd gnd N L=0.044U W=0.044U
Mnmos@55 net@485 net@477 gnd gnd N L=0.044U W=0.044U
Mnmos@56 net@486 net@485 gnd gnd N L=0.044U W=0.044U
Mnmos@57 net@709 net@486 gnd gnd N L=0.044U W=0.044U
Mnmos@58 net@764 net@709 gnd gnd N L=0.044U W=0.044U
Mnmos@59 net@742 net@764 gnd gnd N L=0.044U W=0.044U
Mnmos@60 net@548 net@489 gnd gnd N L=0.044U W=0.044U
Mnmos@61 net@499 net@548 gnd gnd N L=0.044U W=0.044U
Mnmos@62 net@502 net@499 gnd gnd N L=0.044U W=0.044U
Mnmos@63 net@492 net@502 gnd gnd N L=0.044U W=0.044U
Mnmos@64 net@491 net@492 gnd gnd N L=0.044U W=0.044U
Mnmos@65 net@500 net@491 gnd gnd N L=0.044U W=0.044U
Mnmos@66 net@501 net@500 gnd gnd N L=0.044U W=0.044U
Mnmos@67 net@526 net@501 gnd gnd N L=0.044U W=0.044U
Mnmos@68 net@532 net@526 gnd gnd N L=0.044U W=0.044U
Mnmos@69 net@529 net@532 gnd gnd N L=0.044U W=0.044U
Mnmos@70 net@649 net@590 gnd gnd N L=0.044U W=0.044U
Mnmos@71 net@600 net@649 gnd gnd N L=0.044U W=0.044U
Mnmos@72 net@603 net@600 gnd gnd N L=0.044U W=0.044U
Mnmos@73 net@593 net@603 gnd gnd N L=0.044U W=0.044U
Mnmos@74 net@592 net@593 gnd gnd N L=0.044U W=0.044U
Mnmos@75 net@601 net@592 gnd gnd N L=0.044U W=0.044U
Mnmos@76 net@602 net@601 gnd gnd N L=0.044U W=0.044U
Mnmos@77 net@627 net@602 gnd gnd N L=0.044U W=0.044U
Mnmos@78 net@633 net@627 gnd gnd N L=0.044U W=0.044U
Mnmos@79 net@630 net@633 gnd gnd N L=0.044U W=0.044U
Mnmos@80 net@750 net@690 gnd gnd N L=0.044U W=0.044U
Mnmos@81 net@701 net@750 gnd gnd N L=0.044U W=0.044U
Mnmos@82 net@704 net@701 gnd gnd N L=0.044U W=0.044U
Mnmos@83 net@693 net@704 gnd gnd N L=0.044U W=0.044U
Mnmos@84 net@692 net@693 gnd gnd N L=0.044U W=0.044U
Mnmos@85 net@702 net@692 gnd gnd N L=0.044U W=0.044U
Mnmos@86 net@703 net@702 gnd gnd N L=0.044U W=0.044U
Mnmos@87 net@728 net@703 gnd gnd N L=0.044U W=0.044U
Mnmos@88 net@734 net@728 gnd gnd N L=0.044U W=0.044U
Mnmos@89 net@732 net@734 gnd gnd N L=0.044U W=0.044U
Mnmos@90 net@851 net@791 gnd gnd N L=0.044U W=0.044U
Mnmos@91 net@801 net@851 gnd gnd N L=0.044U W=0.044U
Mnmos@92 net@804 net@801 gnd gnd N L=0.044U W=0.044U
Mnmos@93 net@794 net@804 gnd gnd N L=0.044U W=0.044U
Mnmos@94 net@793 net@794 gnd gnd N L=0.044U W=0.044U
Mnmos@95 net@802 net@793 gnd gnd N L=0.044U W=0.044U
Mnmos@96 net@803 net@802 gnd gnd N L=0.044U W=0.044U
Mnmos@97 net@829 net@803 gnd gnd N L=0.044U W=0.044U
Mnmos@98 net@835 net@829 gnd gnd N L=0.044U W=0.044U
Mnmos@99 net@833 net@835 gnd gnd N L=0.044U W=0.044U
Mpmos@0 vdd net@1 net@52 vdd P L=0.044U W=0.044U
Mpmos@1 vdd net@52 net@81 vdd P L=0.044U W=0.044U
Mpmos@2 vdd net@81 net@11 vdd P L=0.044U W=0.044U
Mpmos@3 vdd net@11 net@15 vdd P L=0.044U W=0.044U
Mpmos@4 vdd net@15 net@20 vdd P L=0.044U W=0.044U
Mpmos@5 vdd net@20 net@24 vdd P L=0.044U W=0.044U
Mpmos@6 vdd net@24 net@27 vdd P L=0.044U W=0.044U
Mpmos@7 vdd net@27 net@31 vdd P L=0.044U W=0.044U
Mpmos@8 vdd net@31 net@36 vdd P L=0.044U W=0.044U
Mpmos@9 vdd net@36 net@34 vdd P L=0.044U W=0.044U
Mpmos@10 vdd net@111 net@165 vdd P L=0.044U W=0.044U
Mpmos@11 vdd net@165 net@120 vdd P L=0.044U W=0.044U
Mpmos@12 vdd net@120 net@123 vdd P L=0.044U W=0.044U
Mpmos@13 vdd net@123 net@114 vdd P L=0.044U W=0.044U
Mpmos@14 vdd net@114 net@113 vdd P L=0.044U W=0.044U
Mpmos@15 vdd net@113 net@121 vdd P L=0.044U W=0.044U
Mpmos@16 vdd net@121 net@122 vdd P L=0.044U W=0.044U
Mpmos@17 vdd net@122 net@145 vdd P L=0.044U W=0.044U
Mpmos@18 vdd net@145 net@150 vdd P L=0.044U W=0.044U
Mpmos@19 vdd net@150 net@148 vdd P L=0.044U W=0.044U
Mpmos@20 vdd net@202 net@256 vdd P L=0.044U W=0.044U
Mpmos@21 vdd net@256 net@211 vdd P L=0.044U W=0.044U
Mpmos@22 vdd net@211 net@214 vdd P L=0.044U W=0.044U
Mpmos@23 vdd net@214 net@205 vdd P L=0.044U W=0.044U
Mpmos@24 vdd net@205 net@204 vdd P L=0.044U W=0.044U
Mpmos@25 vdd net@204 net@212 vdd P L=0.044U W=0.044U
Mpmos@26 vdd net@212 net@213 vdd P L=0.044U W=0.044U
Mpmos@27 vdd net@213 net@236 vdd P L=0.044U W=0.044U
Mpmos@28 vdd net@236 net@241 vdd P L=0.044U W=0.044U
Mpmos@29 vdd net@241 net@239 vdd P L=0.044U W=0.044U
Mpmos@30 vdd net@293 net@347 vdd P L=0.044U W=0.044U
Mpmos@31 vdd net@347 net@302 vdd P L=0.044U W=0.044U
Mpmos@32 vdd net@302 net@305 vdd P L=0.044U W=0.044U
Mpmos@33 vdd net@305 net@296 vdd P L=0.044U W=0.044U
Mpmos@34 vdd net@296 net@295 vdd P L=0.044U W=0.044U
Mpmos@35 vdd net@295 net@303 vdd P L=0.044U W=0.044U
Mpmos@36 vdd net@303 net@304 vdd P L=0.044U W=0.044U
Mpmos@37 vdd net@304 net@327 vdd P L=0.044U W=0.044U
Mpmos@38 vdd net@327 net@332 vdd P L=0.044U W=0.044U
Mpmos@39 vdd net@332 net@330 vdd P L=0.044U W=0.044U
Mpmos@40 vdd net@384 net@438 vdd P L=0.044U W=0.044U
Mpmos@41 vdd net@438 net@393 vdd P L=0.044U W=0.044U
Mpmos@42 vdd net@393 net@396 vdd P L=0.044U W=0.044U
Mpmos@43 vdd net@396 net@387 vdd P L=0.044U W=0.044U
Mpmos@44 vdd net@387 net@386 vdd P L=0.044U W=0.044U
Mpmos@45 vdd net@386 net@394 vdd P L=0.044U W=0.044U
Mpmos@46 vdd net@394 net@395 vdd P L=0.044U W=0.044U
Mpmos@47 vdd net@395 net@418 vdd P L=0.044U W=0.044U
Mpmos@48 vdd net@418 net@423 vdd P L=0.044U W=0.044U
Mpmos@49 vdd net@423 net@421 vdd P L=0.044U W=0.044U
Mpmos@50 vdd net@475 net@893 vdd P L=0.044U W=0.044U
Mpmos@51 vdd net@893 net@484 vdd P L=0.044U W=0.044U
Mpmos@52 vdd net@484 net@487 vdd P L=0.044U W=0.044U
Mpmos@53 vdd net@487 net@478 vdd P L=0.044U W=0.044U
Mpmos@54 vdd net@478 net@477 vdd P L=0.044U W=0.044U
Mpmos@55 vdd net@477 net@485 vdd P L=0.044U W=0.044U
Mpmos@56 vdd net@485 net@486 vdd P L=0.044U W=0.044U
Mpmos@57 vdd net@486 net@709 vdd P L=0.044U W=0.044U
Mpmos@58 vdd net@709 net@764 vdd P L=0.044U W=0.044U
Mpmos@59 vdd net@764 net@742 vdd P L=0.044U W=0.044U
Mpmos@60 vdd net@489 net@548 vdd P L=0.044U W=0.044U
Mpmos@61 vdd net@548 net@499 vdd P L=0.044U W=0.044U
Mpmos@62 vdd net@499 net@502 vdd P L=0.044U W=0.044U
Mpmos@63 vdd net@502 net@492 vdd P L=0.044U W=0.044U
Mpmos@64 vdd net@492 net@491 vdd P L=0.044U W=0.044U
Mpmos@65 vdd net@491 net@500 vdd P L=0.044U W=0.044U
Mpmos@66 vdd net@500 net@501 vdd P L=0.044U W=0.044U
Mpmos@67 vdd net@501 net@526 vdd P L=0.044U W=0.044U
Mpmos@68 vdd net@526 net@532 vdd P L=0.044U W=0.044U
Mpmos@69 vdd net@532 net@529 vdd P L=0.044U W=0.044U
Mpmos@70 vdd net@590 net@649 vdd P L=0.044U W=0.044U
Mpmos@71 vdd net@649 net@600 vdd P L=0.044U W=0.044U
Mpmos@72 vdd net@600 net@603 vdd P L=0.044U W=0.044U
Mpmos@73 vdd net@603 net@593 vdd P L=0.044U W=0.044U
Mpmos@74 vdd net@593 net@592 vdd P L=0.044U W=0.044U
Mpmos@75 vdd net@592 net@601 vdd P L=0.044U W=0.044U
Mpmos@76 vdd net@601 net@602 vdd P L=0.044U W=0.044U
Mpmos@77 vdd net@602 net@627 vdd P L=0.044U W=0.044U
Mpmos@78 vdd net@627 net@633 vdd P L=0.044U W=0.044U
Mpmos@79 vdd net@633 net@630 vdd P L=0.044U W=0.044U
Mpmos@80 vdd net@690 net@750 vdd P L=0.044U W=0.044U
Mpmos@81 vdd net@750 net@701 vdd P L=0.044U W=0.044U
Mpmos@82 vdd net@701 net@704 vdd P L=0.044U W=0.044U
Mpmos@83 vdd net@704 net@693 vdd P L=0.044U W=0.044U
Mpmos@84 vdd net@693 net@692 vdd P L=0.044U W=0.044U
Mpmos@85 vdd net@692 net@702 vdd P L=0.044U W=0.044U
Mpmos@86 vdd net@702 net@703 vdd P L=0.044U W=0.044U
Mpmos@87 vdd net@703 net@728 vdd P L=0.044U W=0.044U
Mpmos@88 vdd net@728 net@734 vdd P L=0.044U W=0.044U
Mpmos@89 vdd net@734 net@732 vdd P L=0.044U W=0.044U
Mpmos@90 vdd net@791 net@851 vdd P L=0.044U W=0.044U
Mpmos@91 vdd net@851 net@801 vdd P L=0.044U W=0.044U
Mpmos@92 vdd net@801 net@804 vdd P L=0.044U W=0.044U
Mpmos@93 vdd net@804 net@794 vdd P L=0.044U W=0.044U
Mpmos@94 vdd net@794 net@793 vdd P L=0.044U W=0.044U
Mpmos@95 vdd net@793 net@802 vdd P L=0.044U W=0.044U
Mpmos@96 vdd net@802 net@803 vdd P L=0.044U W=0.044U
Mpmos@97 vdd net@803 net@829 vdd P L=0.044U W=0.044U
Mpmos@98 vdd net@829 net@835 vdd P L=0.044U W=0.044U
Mpmos@99 vdd net@835 net@833 vdd P L=0.044U W=0.044U
VVDC@0 vdd gnd DC 1V AC 0V 0
VVDC@1 net@1 gnd DC 0.5V AC 0V 0
VVDC@2 net@111 gnd DC 0.5V AC 0V 0
VVDC@3 net@202 gnd DC 0.5V AC 0V 0
VVDC@4 net@293 gnd DC 0.5V AC 0V 0
VVDC@5 net@384 gnd DC 0.5V AC 0V 0
VVDC@6 net@475 gnd DC 0.5V AC 0V 0
VVDC@7 net@489 gnd DC 0.5V AC 0V 0
VVDC@8 net@590 gnd DC 0.5V AC 0V 0
VVDC@9 net@690 gnd DC 0.5V AC 0V 0
VVDC@10 net@791 gnd DC 0.5V AC 0V 0
.END
