*** SPICE deck for cell 100T_test{sch} from library CUDA_SPICE
*** Created on Fri Dec 07, 2018 16:33:17
*** Last revised on Fri Dec 07, 2018 16:51:18
*** Written on Fri Dec 07, 2018 16:52:49 by Electric VLSI Design System, version 9.07
*** Layout tech: mocmos, foundry MOSIS
*** UC SPICE *** , MIN_RESIST 4.0, MIN_CAPAC 0.1FF
* Model cards are described in this file:
.include "C:\Users\Angelinia\Documents\ESE 370\Electric\22nm_HP.pm"

.global gnd vdd

*** TOP LEVEL CELL: 100T_test{sch}
Mnmos@0 net@82 net@3 gnd gnd N L=0.044U W=0.044U
Mnmos@1 net@82 net@3 gnd gnd N L=0.044U W=0.044U
Mnmos@2 net@82 net@3 gnd gnd N L=0.044U W=0.044U
Mnmos@3 net@82 net@3 gnd gnd N L=0.044U W=0.044U
Mnmos@4 net@82 net@3 gnd gnd N L=0.044U W=0.044U
Mnmos@5 net@82 net@3 gnd gnd N L=0.044U W=0.044U
Mnmos@6 net@82 net@3 gnd gnd N L=0.044U W=0.044U
Mnmos@7 net@82 net@3 gnd gnd N L=0.044U W=0.044U
Mnmos@8 net@82 net@3 gnd gnd N L=0.044U W=0.044U
Mnmos@9 net@82 net@3 gnd gnd N L=0.044U W=0.044U
Mnmos@10 net@105 net@82 gnd gnd N L=0.044U W=0.044U
Mnmos@11 net@105 net@82 gnd gnd N L=0.044U W=0.044U
Mnmos@12 net@105 net@82 gnd gnd N L=0.044U W=0.044U
Mnmos@13 net@126 net@105 gnd gnd N L=0.044U W=0.044U
Mnmos@14 net@126 net@105 gnd gnd N L=0.044U W=0.044U
Mnmos@15 net@126 net@105 gnd gnd N L=0.044U W=0.044U
Mnmos@16 net@148 net@126 gnd gnd N L=0.044U W=0.044U
Mnmos@17 net@148 net@126 gnd gnd N L=0.044U W=0.044U
Mnmos@18 net@148 net@126 gnd gnd N L=0.044U W=0.044U
Mnmos@19 net@170 net@148 gnd gnd N L=0.044U W=0.044U
Mnmos@20 net@170 net@148 gnd gnd N L=0.044U W=0.044U
Mnmos@21 net@170 net@148 gnd gnd N L=0.044U W=0.044U
Mnmos@22 net@193 net@170 gnd gnd N L=0.044U W=0.044U
Mnmos@23 net@193 net@170 gnd gnd N L=0.044U W=0.044U
Mnmos@24 net@193 net@170 gnd gnd N L=0.044U W=0.044U
Mnmos@25 net@215 net@193 gnd gnd N L=0.044U W=0.044U
Mnmos@26 net@215 net@193 gnd gnd N L=0.044U W=0.044U
Mnmos@27 net@215 net@193 gnd gnd N L=0.044U W=0.044U
Mnmos@28 net@237 net@215 gnd gnd N L=0.044U W=0.044U
Mnmos@29 net@237 net@215 gnd gnd N L=0.044U W=0.044U
Mnmos@30 net@237 net@215 gnd gnd N L=0.044U W=0.044U
Mnmos@31 net@258 net@237 gnd gnd N L=0.044U W=0.044U
Mnmos@32 net@258 net@237 gnd gnd N L=0.044U W=0.044U
Mnmos@33 net@258 net@237 gnd gnd N L=0.044U W=0.044U
Mnmos@34 net@256 net@258 gnd gnd N L=0.044U W=0.044U
Mnmos@35 net@266 net@258 gnd gnd N L=0.044U W=0.044U
Mnmos@36 net@272 net@258 gnd gnd N L=0.044U W=0.044U
Mnmos@37 net@105 net@82 gnd gnd N L=0.044U W=0.044U
Mnmos@38 net@105 net@82 gnd gnd N L=0.044U W=0.044U
Mnmos@39 net@105 net@82 gnd gnd N L=0.044U W=0.044U
Mnmos@40 net@126 net@105 gnd gnd N L=0.044U W=0.044U
Mnmos@41 net@126 net@105 gnd gnd N L=0.044U W=0.044U
Mnmos@42 net@126 net@105 gnd gnd N L=0.044U W=0.044U
Mnmos@43 net@148 net@126 gnd gnd N L=0.044U W=0.044U
Mnmos@44 net@148 net@126 gnd gnd N L=0.044U W=0.044U
Mnmos@45 net@148 net@126 gnd gnd N L=0.044U W=0.044U
Mnmos@46 net@170 net@148 gnd gnd N L=0.044U W=0.044U
Mnmos@47 net@170 net@148 gnd gnd N L=0.044U W=0.044U
Mnmos@48 net@170 net@148 gnd gnd N L=0.044U W=0.044U
Mnmos@49 net@193 net@170 gnd gnd N L=0.044U W=0.044U
Mnmos@50 net@193 net@170 gnd gnd N L=0.044U W=0.044U
Mnmos@51 net@193 net@170 gnd gnd N L=0.044U W=0.044U
Mnmos@52 net@215 net@193 gnd gnd N L=0.044U W=0.044U
Mnmos@53 net@215 net@193 gnd gnd N L=0.044U W=0.044U
Mnmos@54 net@215 net@193 gnd gnd N L=0.044U W=0.044U
Mnmos@55 net@237 net@215 gnd gnd N L=0.044U W=0.044U
Mnmos@56 net@237 net@215 gnd gnd N L=0.044U W=0.044U
Mnmos@57 net@404 net@215 gnd gnd N L=0.044U W=0.044U
Mnmos@58 net@258 net@237 gnd gnd N L=0.044U W=0.044U
Mnmos@59 net@258 net@237 gnd gnd N L=0.044U W=0.044U
Mnmos@60 net@258 net@237 gnd gnd N L=0.044U W=0.044U
Mnmos@61 net@452 net@258 gnd gnd N L=0.044U W=0.044U
Mnmos@62 net@454 net@258 gnd gnd N L=0.044U W=0.044U
Mnmos@63 net@444 net@258 gnd gnd N L=0.044U W=0.044U
Mnmos@64 net@105 net@82 gnd gnd N L=0.044U W=0.044U
Mnmos@65 net@105 net@82 gnd gnd N L=0.044U W=0.044U
Mnmos@66 net@105 net@82 gnd gnd N L=0.044U W=0.044U
Mnmos@67 net@126 net@105 gnd gnd N L=0.044U W=0.044U
Mnmos@68 net@126 net@105 gnd gnd N L=0.044U W=0.044U
Mnmos@69 net@126 net@105 gnd gnd N L=0.044U W=0.044U
Mnmos@70 net@148 net@126 gnd gnd N L=0.044U W=0.044U
Mnmos@71 net@148 net@126 gnd gnd N L=0.044U W=0.044U
Mnmos@72 net@148 net@126 gnd gnd N L=0.044U W=0.044U
Mnmos@73 net@170 net@148 gnd gnd N L=0.044U W=0.044U
Mnmos@74 net@170 net@148 gnd gnd N L=0.044U W=0.044U
Mnmos@75 net@170 net@148 gnd gnd N L=0.044U W=0.044U
Mnmos@76 net@193 net@170 gnd gnd N L=0.044U W=0.044U
Mnmos@77 net@193 net@170 gnd gnd N L=0.044U W=0.044U
Mnmos@78 net@193 net@170 gnd gnd N L=0.044U W=0.044U
Mnmos@79 net@215 net@193 gnd gnd N L=0.044U W=0.044U
Mnmos@80 net@215 net@193 gnd gnd N L=0.044U W=0.044U
Mnmos@81 net@215 net@193 gnd gnd N L=0.044U W=0.044U
Mnmos@82 net@237 net@215 gnd gnd N L=0.044U W=0.044U
Mnmos@83 net@237 net@215 gnd gnd N L=0.044U W=0.044U
Mnmos@84 net@237 net@215 gnd gnd N L=0.044U W=0.044U
Mnmos@85 net@258 net@237 gnd gnd N L=0.044U W=0.044U
Mnmos@86 net@258 net@237 gnd gnd N L=0.044U W=0.044U
Mnmos@87 net@258 net@237 gnd gnd N L=0.044U W=0.044U
Mnmos@88 net@632 net@258 gnd gnd N L=0.044U W=0.044U
Mnmos@89 net@634 net@258 gnd gnd N L=0.044U W=0.044U
Mnmos@90 net@624 net@258 gnd gnd N L=0.044U W=0.044U
Mnmos@91 net@105 net@82 gnd gnd N L=0.044U W=0.044U
Mnmos@92 net@126 net@105 gnd gnd N L=0.044U W=0.044U
Mnmos@93 net@148 net@126 gnd gnd N L=0.044U W=0.044U
Mnmos@94 net@170 net@148 gnd gnd N L=0.044U W=0.044U
Mnmos@95 net@193 net@170 gnd gnd N L=0.044U W=0.044U
Mnmos@96 net@215 net@193 gnd gnd N L=0.044U W=0.044U
Mnmos@97 net@237 net@215 gnd gnd N L=0.044U W=0.044U
Mnmos@98 net@258 net@237 gnd gnd N L=0.044U W=0.044U
Mnmos@99 net@1163 net@258 gnd gnd N L=0.044U W=0.044U
Mpmos@0 vdd net@3 net@82 vdd P L=0.044U W=0.044U
Mpmos@1 vdd net@3 net@82 vdd P L=0.044U W=0.044U
Mpmos@2 vdd net@3 net@82 vdd P L=0.044U W=0.044U
Mpmos@3 vdd net@3 net@82 vdd P L=0.044U W=0.044U
Mpmos@4 vdd net@3 net@82 vdd P L=0.044U W=0.044U
Mpmos@5 vdd net@3 net@82 vdd P L=0.044U W=0.044U
Mpmos@6 vdd net@3 net@82 vdd P L=0.044U W=0.044U
Mpmos@7 vdd net@3 net@82 vdd P L=0.044U W=0.044U
Mpmos@8 vdd net@3 net@82 vdd P L=0.044U W=0.044U
Mpmos@9 vdd net@3 net@82 vdd P L=0.044U W=0.044U
Mpmos@10 vdd net@82 net@105 vdd P L=0.044U W=0.044U
Mpmos@11 vdd net@82 net@105 vdd P L=0.044U W=0.044U
Mpmos@12 vdd net@82 net@105 vdd P L=0.044U W=0.044U
Mpmos@13 vdd net@105 net@126 vdd P L=0.044U W=0.044U
Mpmos@14 vdd net@105 net@126 vdd P L=0.044U W=0.044U
Mpmos@15 vdd net@105 net@126 vdd P L=0.044U W=0.044U
Mpmos@16 vdd net@126 net@148 vdd P L=0.044U W=0.044U
Mpmos@17 vdd net@126 net@148 vdd P L=0.044U W=0.044U
Mpmos@18 vdd net@126 net@148 vdd P L=0.044U W=0.044U
Mpmos@19 vdd net@148 net@170 vdd P L=0.044U W=0.044U
Mpmos@20 vdd net@148 net@170 vdd P L=0.044U W=0.044U
Mpmos@21 vdd net@148 net@170 vdd P L=0.044U W=0.044U
Mpmos@22 vdd net@170 net@193 vdd P L=0.044U W=0.044U
Mpmos@23 vdd net@170 net@193 vdd P L=0.044U W=0.044U
Mpmos@24 vdd net@170 net@193 vdd P L=0.044U W=0.044U
Mpmos@25 vdd net@193 net@215 vdd P L=0.044U W=0.044U
Mpmos@26 vdd net@193 net@215 vdd P L=0.044U W=0.044U
Mpmos@27 vdd net@193 net@215 vdd P L=0.044U W=0.044U
Mpmos@28 vdd net@215 net@237 vdd P L=0.044U W=0.044U
Mpmos@29 vdd net@215 net@237 vdd P L=0.044U W=0.044U
Mpmos@30 vdd net@215 net@237 vdd P L=0.044U W=0.044U
Mpmos@31 vdd net@237 net@258 vdd P L=0.044U W=0.044U
Mpmos@32 vdd net@237 net@258 vdd P L=0.044U W=0.044U
Mpmos@33 vdd net@237 net@258 vdd P L=0.044U W=0.044U
Mpmos@34 vdd net@258 net@256 vdd P L=0.044U W=0.044U
Mpmos@35 vdd net@258 net@266 vdd P L=0.044U W=0.044U
Mpmos@36 vdd net@258 net@272 vdd P L=0.044U W=0.044U
Mpmos@37 vdd net@82 net@105 vdd P L=0.044U W=0.044U
Mpmos@38 vdd net@82 net@105 vdd P L=0.044U W=0.044U
Mpmos@39 vdd net@82 net@105 vdd P L=0.044U W=0.044U
Mpmos@40 vdd net@105 net@126 vdd P L=0.044U W=0.044U
Mpmos@41 vdd net@105 net@126 vdd P L=0.044U W=0.044U
Mpmos@42 vdd net@105 net@126 vdd P L=0.044U W=0.044U
Mpmos@43 vdd net@126 net@148 vdd P L=0.044U W=0.044U
Mpmos@44 vdd net@126 net@148 vdd P L=0.044U W=0.044U
Mpmos@45 vdd net@126 net@148 vdd P L=0.044U W=0.044U
Mpmos@46 vdd net@148 net@170 vdd P L=0.044U W=0.044U
Mpmos@47 vdd net@148 net@170 vdd P L=0.044U W=0.044U
Mpmos@48 vdd net@148 net@170 vdd P L=0.044U W=0.044U
Mpmos@49 vdd net@170 net@193 vdd P L=0.044U W=0.044U
Mpmos@50 vdd net@170 net@193 vdd P L=0.044U W=0.044U
Mpmos@51 vdd net@170 net@193 vdd P L=0.044U W=0.044U
Mpmos@52 vdd net@193 net@215 vdd P L=0.044U W=0.044U
Mpmos@53 vdd net@193 net@215 vdd P L=0.044U W=0.044U
Mpmos@54 vdd net@193 net@215 vdd P L=0.044U W=0.044U
Mpmos@55 vdd net@215 net@237 vdd P L=0.044U W=0.044U
Mpmos@56 vdd net@215 net@237 vdd P L=0.044U W=0.044U
Mpmos@57 vdd net@215 net@404 vdd P L=0.044U W=0.044U
Mpmos@58 vdd net@237 net@258 vdd P L=0.044U W=0.044U
Mpmos@59 vdd net@237 net@258 vdd P L=0.044U W=0.044U
Mpmos@60 vdd net@237 net@258 vdd P L=0.044U W=0.044U
Mpmos@61 vdd net@258 net@452 vdd P L=0.044U W=0.044U
Mpmos@62 vdd net@258 net@454 vdd P L=0.044U W=0.044U
Mpmos@63 vdd net@258 net@444 vdd P L=0.044U W=0.044U
Mpmos@64 vdd net@82 net@105 vdd P L=0.044U W=0.044U
Mpmos@65 vdd net@82 net@105 vdd P L=0.044U W=0.044U
Mpmos@66 vdd net@82 net@105 vdd P L=0.044U W=0.044U
Mpmos@67 vdd net@105 net@126 vdd P L=0.044U W=0.044U
Mpmos@68 vdd net@105 net@126 vdd P L=0.044U W=0.044U
Mpmos@69 vdd net@105 net@126 vdd P L=0.044U W=0.044U
Mpmos@70 vdd net@126 net@148 vdd P L=0.044U W=0.044U
Mpmos@71 vdd net@126 net@148 vdd P L=0.044U W=0.044U
Mpmos@72 vdd net@126 net@148 vdd P L=0.044U W=0.044U
Mpmos@73 vdd net@148 net@170 vdd P L=0.044U W=0.044U
Mpmos@74 vdd net@148 net@170 vdd P L=0.044U W=0.044U
Mpmos@75 vdd net@148 net@170 vdd P L=0.044U W=0.044U
Mpmos@76 vdd net@170 net@193 vdd P L=0.044U W=0.044U
Mpmos@77 vdd net@170 net@193 vdd P L=0.044U W=0.044U
Mpmos@78 vdd net@170 net@193 vdd P L=0.044U W=0.044U
Mpmos@79 vdd net@193 net@215 vdd P L=0.044U W=0.044U
Mpmos@80 vdd net@193 net@215 vdd P L=0.044U W=0.044U
Mpmos@81 vdd net@193 net@215 vdd P L=0.044U W=0.044U
Mpmos@82 vdd net@215 net@237 vdd P L=0.044U W=0.044U
Mpmos@83 vdd net@215 net@237 vdd P L=0.044U W=0.044U
Mpmos@84 vdd net@215 net@237 vdd P L=0.044U W=0.044U
Mpmos@85 vdd net@237 net@258 vdd P L=0.044U W=0.044U
Mpmos@86 vdd net@237 net@258 vdd P L=0.044U W=0.044U
Mpmos@87 vdd net@237 net@258 vdd P L=0.044U W=0.044U
Mpmos@88 vdd net@258 net@632 vdd P L=0.044U W=0.044U
Mpmos@89 vdd net@258 net@634 vdd P L=0.044U W=0.044U
Mpmos@90 vdd net@258 net@624 vdd P L=0.044U W=0.044U
Mpmos@91 vdd net@82 net@105 vdd P L=0.044U W=0.044U
Mpmos@92 vdd net@105 net@126 vdd P L=0.044U W=0.044U
Mpmos@93 vdd net@126 net@148 vdd P L=0.044U W=0.044U
Mpmos@94 vdd net@148 net@170 vdd P L=0.044U W=0.044U
Mpmos@95 vdd net@170 net@193 vdd P L=0.044U W=0.044U
Mpmos@96 vdd net@193 net@215 vdd P L=0.044U W=0.044U
Mpmos@97 vdd net@215 net@237 vdd P L=0.044U W=0.044U
Mpmos@98 vdd net@237 net@258 vdd P L=0.044U W=0.044U
Mpmos@99 vdd net@258 net@1163 vdd P L=0.044U W=0.044U
VVDC@0 vdd gnd DC 1V AC 0V 0
VVDC@1 net@3 gnd DC 0.5V AC 0V 0
.END
